.include<m328pdef.inc>

.cseg
.org 0x00
	LDI	R16,HIGH(RAMEND)	
	OUT	SPH,R16
	LDI	R16,LOW(RAMEND) 
	OUT	SPL,R16				
	LDI	R16,0xFF		
	OUT	DDRB,R16		
BACK:
	COM	R16			
	OUT 	PORTB,R16		
	CALL	DELAY			
	RJMP	BACK			

DELAY:
	LDI	R20,16
L1:	LDI	R21,200
L2:	LDI	R22,250
L3:	
	NOP
	NOP
	DEC	R22
	BRNE	L3
	DEC	R21
	BRNE	L2
	DEC	R20
	BRNE	L1
	RET